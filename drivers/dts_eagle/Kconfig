## drivers/dts_eagle/Kconfig
```kconfig
config DTS_EAGLE
	tristate "DTS Eagle driver"
	depends on AINUR_DTS_HW
	default y if AINUR_DTS_HW
	help
	  DTS Eagle module.
```
